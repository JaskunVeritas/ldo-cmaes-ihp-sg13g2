** sch_path: designs/1iee34/loopgainprobe.sch
**.subckt loopgainprobe a b
*.iopin a
*.iopin b
Vi x a dc 0 ac 1
Ii GND x dc 0 ac 0
Vnodebuffer b x 0
**.ends
.GLOBAL GND
.end
